# Keil uVision project STM32_UART_CMD.uvprojx, settings and files
target V1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CMSIS;..\DRIVERS;..\LIB\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group BSP
    ../BSP/: board.c board.h Emm_V5.c Emm_V5.h usart.c usart.h
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group DRIVERS
    ../DRIVERS/: fifo.c fifo.h delay.c delay.h
  group LIB
    ../LIB/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c misc.c
